# Keil uVision project eXin.uvprojx, settings and files
target eXin STM32F103C8 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: eXin +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,HSE_VALUE=8000000
  c misc: --no-multibyte-chars
  c include: .;..\Application;..\Protocol;..\Vendor\LocalSPL\Start;..\Vendor\LocalSPL\Library;..\Drivers\Control;..\Drivers\Encoder;..\Drivers\I2C;..\Drivers\IMU;..\Drivers\Key;..\Drivers\OLED;..\Drivers\Power;..\Drivers\PWM;..\Drivers\RTC;..\Drivers\Serial;..\Drivers\Bluetooth;..\Drivers\Timebase
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\eXin.sct
  group Application
    ../Application/: app.c main.c ui_core.c
  group Protocol
    ../Protocol/: protocol.c
  group Driver Control
    ../Drivers/Control/: control.c
  group Driver Encoder
    ../Drivers/Encoder/: encoder_core.c encoder.c
  group Driver I2C
    ../Drivers/I2C/: i2c_bus.c
  group Driver IMU
    ../Drivers/IMU/: imu_core.c imu.c
  group Driver Key
    ../Drivers/Key/: key_core.c key.c
  group Driver OLED
    ../Drivers/OLED/: OLED_Data_ASCII.c OLED_Data_Hanzi.c oled_gfx.c oled.c
  group Driver Power
    ../Drivers/Power/: power_core.c power.c
  group Driver PWM
    ../Drivers/PWM/: pwm_core.c pwm.c
  group Driver RTC
    ../Drivers/RTC/: rtc_clock.c rtc_core.c
  group Driver Serial
    ../Drivers/Serial/: serial_ring.c serial.c
    ../Drivers/Bluetooth/: bluetooth.c
  group Driver Timebase
    ../Drivers/Timebase/: timebase.c
  group ST Standard Peripheral Library
    ../Vendor/LocalSPL/Library/: stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c misc.c
  group Startup CMSIS
    ./: startup_stm32f10x_md_keil.s
    ../Vendor/LocalSPL/Start/: system_stm32f10x.c core_cm3.c
